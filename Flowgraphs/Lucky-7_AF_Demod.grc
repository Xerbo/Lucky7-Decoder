options:
  parameters:
    author: Xerbo
    generate_options: qt_gui
    id: Lucky-7_AF_Demod
    output_language: python
    run_options: run
    title: Lucky-7 AF Demod
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: SDRSharp_20201113_171612Z_437527600Hz_AF.bin
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: '35'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: SDRSharp_20201113_171612Z_437527600Hz_AF.wav
    repeat: 'False'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'True'
    type: ff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: satellites_satellite_decoder_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    file: AAUSAT-4
    name: Lucky-7
    norad: ''
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', dc_blocker_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', satellites_satellite_decoder_0_0, '0']
- [satellites_satellite_decoder_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
