options:
  parameters:
    author: Xerbo
    generate_options: qt_gui
    id: lucky7iqdemod
    output_language: python
    title: Lucky-7 IQ Demod
  states: {}

blocks:
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '93750'
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.0010e-7'
    reference: '1'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: 13-07-48_437525000Hz.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: 13-07-48_437525000Hz.wav
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: '35'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'True'
    type: ff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_satellite_decoder_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    file: AAUSAT-4
    name: Lucky-7
    norad: ''
    samp_rate: samp_rate
  states: {}

connections:
- [analog_agc_xx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_agc_xx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc_xx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', analog_agc_xx_0_0, '0']
- [dc_blocker_xx_0, '0', satellites_satellite_decoder_0_0, '0']
- [satellites_satellite_decoder_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
